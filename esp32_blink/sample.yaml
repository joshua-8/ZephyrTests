## esp32_blink/sample.yaml
```yaml
sample:
  description: simple blink example configured for an ESP32
  name: esp32 blink
```
